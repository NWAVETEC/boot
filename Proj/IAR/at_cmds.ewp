# IAR project at_cmds.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G210F128 SiliconLaboratories EFM32G210F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32G210F128
  ICCARM.CCIncludePath2: include; emlib\inc; UNB+; ..\src; config_gecko
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at_cmds.srec
  ILINK.IlinkOutputFile: nwave_dev_kit.out
  ILINK.IlinkIcfFile: at_cmds_dbg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EFM32G210F128; NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: nwave_boot.bin
  ILINK.IlinkOutputFile: nwave_dev_kit_boot.out
  ILINK.IlinkIcfFile: at_cmds.icf
  group CMSIS
    CMSIS/: startup_efm32g.c startup_efm32g.s system_efm32g.c
  group emlib
    emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group src
    ../src/: autobaud.c boot.c bootloader.c crc.c debug.c debuglock.c flash.c iarwrite.c leuart.c nwrm_cmu.c nwrm_printf.c nwrm_rtc.c nwrm_uart.c xmodem.c
